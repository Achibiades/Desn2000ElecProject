# Keil uVision project empty_skeleton.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: empty_skeleton
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Sources
    ./sources/: main.c SystemInit.c adc.c alarm_screen.c coffee_screen.c heating.c homepage.c light_screen.c lock_screen.c motion.c rtc.c temp_screen.c songs.c
    ./Sources/: startup_stm32f10x_hd.s
  group Headers
    ./headers/: stm32f103xe.h system_stm32f1xx.h
  group LCD
    ./LCD/: font5x7.c lcd_grph.c lcd_hw.c lcd_ili9341.c
